## Kconfig.projbuild
```kconfig
menu "Sensirion SCD4x Sensor"
    config SCD4X_ADDRESS
        hex
        prompt "CO2 SCD4x Sensor Address"
        default 0x62
endmenu
```
